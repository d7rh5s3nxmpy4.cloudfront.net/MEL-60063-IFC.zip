Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2025-01-28T09:58:04
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: MEL-60063-VN-8040_25D
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: MEL-60063-VN-8040_25D; Light output ratio: 1; Luminous flux: 1720.58 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 1720.58 lm; LightEmitterNominalPower: 28.2 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 549521, 475: 442322, 480: 39367, 485: 37832, 490: 392506, 495: 423255, 500: 468951, 505: 509823, 510: 551923, 515: 57673, 520: 59894, 525: 611155, 530: 623829, 535: 629598, 540: 636475, 545: 645361, 550: 655589, 555: 671682, 560: 690295, 565: 709359, 570: 730587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 821303, 605: 827334, 610: 827494, 615: 819016, 616: 814072, 617: 810179, 618: 806287, 619: 802012, 620: 797737, 625: 764787, 630: 724964, 635: 680899, 640: 638133, 645: 594845, 650: 555125, 655: 51894, 660: 486181, 665: 454614, 670: 422297, 675: 388355, 680: 352992, 685: 318193, 690: 282697, 695: 245701, 700: 215906, 705: 189853, 710: 163229, 715: 14476, 720: 12737, 725: 114158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorTemperature: 4000 K; ColorRenderingIndex: 80

# IfcFlowTerminal: MELBOURNE 7 In-ground luminaires
In: Default Building
Type - Description: - Lamp COB - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour 3000K and 4000K Stainless steel body in grade 316 - Pre-treated before powder coating ensuring highcorrosion resistance - Front ring in grade 316 stainless steel - Adjustable: Tilt 25°, Rotation 360° for ME-60051,ME-60052, ME-60053, ME-60061, ME-60062,ME-60063 - Single cable entry, through wiring upon request - Stainless steel fasteners in grade 316 - Durable silicone rubber gasket - High-efficiency PMMA lens - Clear or frosted toughened glass - Integral control gear - Recessing box in high-density PA66 with 30glass fibers included - Suitable for drive-over with a maximum load of5000 kg - Vehicles with pneumatic tires can drive over theluminaire but the speed must not exceed 50 km/h - Load is transferred by the housing to thefoundation - The distance between the luminaire and theilluminated surface should be at least 0.5 m; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: HARRIER, In-ground luminaires; Housing color: Not specified
General Information - Article number: MEL-60063-VN-8040_25D; Article name: MELBOURNE 7 In-ground luminaires; Weight: 17 kg; Case height: 27 cm; Case diameter: 29 cm; Uld creation date: 28.01.2025 08:58:04
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 28.2 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 28.2 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
